# Keil uVision project NRF_uart_Raspberry.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: nRF51822_xxAB Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.1.0.3
  cpu: IROM(0x00000000,0x20000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: NRF_uart_Raspberry +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: .\project_nrf51\Basic\Include_C;.\project_nrf51\Basic\Include_H;.\project_nrf51\Basic\startup;.\project_nrf51\Peripherals\gcc;.\Include;.\project_nrf51\Peripherals\boards
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Source Group 1
    ./project_nrf51/Basic/startup/: arm_startup_nrf51.s
    ./project_nrf51/Basic/Include_C/nrf_delay/: nrf_delay.c
    ./project_nrf51/Basic/Include_C/nrf_radio/: radio_config.c
    ./project_nrf51/Basic/Include_C/: nrf_gpio.c
    ./project_nrf51/Basic/Include_C/simple_uart/: simple_uart.c
    ./: NRF_uart_Raspberry.c
