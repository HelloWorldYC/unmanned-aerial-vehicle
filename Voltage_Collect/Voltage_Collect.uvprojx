# Keil uVision project Voltage_Collect.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.1.0.3
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Voltage_Collect +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: .\project_nrf51\Basic\Include_C;.\project_nrf51\Basic\Include_H;.\project_nrf51\Basic\startup;.\project_nrf51\Peripherals;.\ADC;.\project_nrf51\Peripherals\app_common;.\project_nrf51\Peripherals\ble\ble_services;.\project_nrf51\Peripherals\ble\rpc;.\project_nrf51\Peripherals\ble\softdevice;.\project_nrf51\Peripherals\boards;.\project_nrf51\Peripherals\esb;.\project_nrf51\Peripherals\ext_sensors;.\project_nrf51\Peripherals\gcc;.\project_nrf51\Peripherals\gzll;.\project_nrf51\Peripherals\gzp;.\project_nrf51\Peripherals\key_scan;.\project_nrf51\Peripherals\radio_config;.\project_nrf51\Basic\Include_C\nrf_radio
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Source Group 1
    ./: Voltage_Collect.c
    ./project_nrf51/Basic/startup/: project_nrf51822.c system_nrf51.c arm_startup_nrf51.s
    ./ADC/: ADC.c
    ./project_nrf51/Basic/Include_C/: nrf_gpio.c
    ./project_nrf51/Basic/Include_C/nrf_delay/: nrf_delay.c
    ./project_nrf51/Basic/Include_C/simple_uart/: simple_uart.c
    ./project_nrf51/Basic/Include_C/nrf_radio/: radio_config.c
